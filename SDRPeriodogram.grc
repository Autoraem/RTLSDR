options:
  parameters:
    author: Winte
    generate_options: qt_gui
    id: SDRPeriodogram
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: FFTLength
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    start: center_freq-30e6
    step: 1e6
    stop: center_freq+30e6
    value: 900e6
  states: {}
- name: frequencyResolution
  id: variable
  parameters:
    value: samp_rate/FFTLength
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '40'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: transmittedFreq
  id: variable
  parameters:
    value: center_freq
  states: {}
- name: blocks_argmax_xx_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: FFTLength
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: FFTLength
  states: {}
- name: blocks_file_sink_0_2
  id: blocks_file_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: FFTLength
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: FFTLength
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(FFTLength)
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: 100e6
    fc: center_freq
    fftsize: FFTLength
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.05'
    vlen: FFTLength
    x_axis_label: '"MHz"'
    x_start: '-1'
    x_step: 2/FFTLength
    x_units: '"MHz"'
    ymin: '0'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    corr0: '20'
    freq0: center_freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_argmax_xx_0, '0', blocks_short_to_float_0, '0']
- [blocks_argmax_xx_0, '1', blocks_null_sink_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_argmax_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_short_to_float_0, '0', blocks_file_sink_0_2, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [rtlsdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [rtlsdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
